# IAR project scr_aka.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0
  General.SCCStackSize: 0x1d0
  General.SCRStackSize: 0x2a
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm88.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: main.c
  group 3gpp-aka
    3gpp-aka/: aka.c sha.c test_sha_based_aka.c
  group iccd
    iccd/: iccd.c
  group scr
    scr/: ccid.c iso7816.c iso7816_line.s90
  group usbdrv
    usbdrv/: oddebug.c usbdrv.c usbdrvasm.s90
